# Keil uVision project thermostat.uvprojx, settings and files
target thermostat_1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: thermostat +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --c99 --diag_suppress=1,550
  c include: ..\CMSIS;..\StdLib_V3.5\inc;..\user\app;..\user\driver;..\user\sys;..\FreeRTOS\include;..\emwin\Config;..\emwin\GUI_X;..\emwin\Demo;..\emwin\Lib;..\emwin\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../CMSIS/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s
  group user/app
    ../user/app/: main.c
  group user/driver
    ../user/driver/: sysflash.c base_conf.c lcd.c sys.c led.c LCD_ILI9488.c uart_dma.c bsp_ds18b20.c timer.c CC1101.c key.c biss_ir.c bsp_i2c_gpio.c bsp_touch.c bsp_ts_ft5x06.c
  group user/sys
    ../user/sys/: stm32f10x_it.c system_stm32f10x.c
  group StdLib_V3.5
    ../StdLib_V3.5/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FreeRTOS/source
    ../FreeRTOS/source/: croutine.c event_groups.c list.c port.c queue.c tasks.c timers.c heap_2.c
  group FreeRTOS/include
    ../FreeRTOS/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h FreeRTOSConfig.h list.h mpu_prototypes.h mpu_wrappers.h portable.h portmacro.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group GUI_X
    ../emwin/GUI_X/: GUI_X_FreeRTOS.c GUI_X_Touch_Analog.c
  group GUI/Config
    ../emwin/Config/: GUIConf.c LCDConf_FlexColor_Template.c GUIDRV_Template.c
  group GUI/Demo
    ../emwin/Demo/: gui_task.c
  group GUI/Lib
    ../emwin/Lib/: STemWin532_CM3_OS_Keil.lib
